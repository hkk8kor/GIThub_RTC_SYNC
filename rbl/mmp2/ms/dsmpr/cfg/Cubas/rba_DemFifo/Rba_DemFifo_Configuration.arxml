<?xml version="1.0" encoding="UTF-8"?>
<AUTOSAR xsi:schemaLocation="http://autosar.org/schema/r4.0 autosar_4-0-1.xsd" xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance">
 <AR-PACKAGES> 
  <AR-PACKAGE>
   <SHORT-NAME>RB</SHORT-NAME>
   <AR-PACKAGES>
    <AR-PACKAGE>
     <SHORT-NAME>UBK</SHORT-NAME>
     <AR-PACKAGES>
      <AR-PACKAGE>
       <SHORT-NAME>Project</SHORT-NAME>
       <AR-PACKAGES>
        <AR-PACKAGE>
         <SHORT-NAME>EcucModuleConfigurationValuess</SHORT-NAME>
        </AR-PACKAGE>
       </AR-PACKAGES>
      </AR-PACKAGE>
     </AR-PACKAGES>
    </AR-PACKAGE>
   </AR-PACKAGES>
  </AR-PACKAGE>
 </AR-PACKAGES>
</AUTOSAR>
<!-- Last modified by AEEE-Pro_2016.2.0 - BCT -->
